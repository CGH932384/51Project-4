# Keil uVision project text.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: text +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: AT24C02.c Delay.c I2C.c Key.c LCD1602.c main.c Timer0.c I2C.h AT24C02.h Delay.h Key.h LCD1602.h Timer0.h
